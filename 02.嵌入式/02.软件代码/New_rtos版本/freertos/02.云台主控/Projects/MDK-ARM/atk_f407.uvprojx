# Keil uVision project atk_f407.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx
  c include: ..\..\User;..\..\Drivers;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Middlewares;..\..\Middlewares\FreeRTOS\include;..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\iic;..\..\Drivers\SYSTEM\spi;..\..\Drivers\SYSTEM\sys;..\..\Drivers\SYSTEM\usart;..\..\Drivers\BSP\BMI088;..\..\Drivers\BSP\IMU;..\..\Drivers\BSP\IST8310;..\..\Drivers\BSP\KEY;..\..\Drivers\BSP\LASER;..\..\Drivers\BSP\LED;..\..\Drivers\BSP\LVBO;..\..\Drivers\BSP\MahonyAHRS;..\..\Drivers\BSP\NRF24L01;..\..\Drivers\BSP\OLED;..\..\Drivers\BSP\PID;..\..\Drivers\BSP\TIMER;..\..\Middlewares\MALLOC;..\..\Drivers\BSP\MY_TASK;..\..\Drivers\BSP\DATA;..\..\Drivers\SYSTEM\iic_hw;..\..\Drivers\BSP\DMA;..\..\Drivers\BSP\WS2812;..\..\Drivers\BSP\BMI055
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../../User/: main.c stm32f4xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
    ../../Drivers/SYSTEM/spi/: spi.c
    ../../Drivers/SYSTEM/iic_hw/: iic_hw.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/TIMER/: btim.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/IMU/: imu.c
    ../../Drivers/BSP/IST8310/: ist8310.c
    ../../Drivers/BSP/LASER/: laser.c
    ../../Drivers/BSP/LVBO/: lvbo.c
    ../../Drivers/BSP/MahonyAHRS/: MahonyAHRS.c
    ../../Drivers/BSP/NRF24L01/: nrf24l01.c
    ../../Drivers/BSP/OLED/: oled.c
    ../../Drivers/BSP/PID/: pid.c
    ../../Drivers/BSP/MY_TASK/: my_task.c
    ../../Drivers/BSP/DATA/: data.c
    ../../Drivers/BSP/WS2812/: ws2812b.c
    ../../Drivers/BSP/BMI055/: bmi055.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/XMRAM
    ../../Middlewares/XMRAM/: XMRAM.h XMRAM.lib
  group Middlewares/FreeRTOS_CORE
    ../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Readme
    ../../: readme.txt
